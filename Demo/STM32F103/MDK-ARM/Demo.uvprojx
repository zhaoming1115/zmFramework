# Keil uVision project Demo.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zmFrameWorkTest +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xE,_MSC_VER,DebugMode=1
  c misc: -fms-extensions -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\STM32F103;..\..\..\zmFrameWork;..\..\Example;..\..\..\zmFrameWork\PLOOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Debug.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c iwdg.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_ll_dma.c stm32f1xx_ll_usart.c stm32f1xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group 平台抽象层
    ../../../zmFrameWork/PAL/zmCOM/: zmCOMBase.c
    ../../../zmFrameWork/PAL/zmCOM/zmSerialPort/: zmSerialPort.c
    ../../../zmFrameWork/PAL/zmGPIO/: zmGPIO.c
    ../../../zmFrameWork/PAL/zmStorage/: zmStorage.c
    ../../../zmFrameWork/PAL/zmPWM/: zmPWM.c
    ../../../zmFrameWork/PAL/zmCOM/zmI2C/: zmI2C.c
    ../../../zmFrameWork/PAL/zmCOM/zmSPI/zmSPIMaster/zmSPISyncMaster/: zmSPISyncMaster.c
  group 系统
    ../../../zmFrameWork/Sys/zmElementInfo/: zmElementInfo.c
    ../../../zmFrameWork/Sys/zmSys/: zmSys.c
    ../../../zmFrameWork/Sys/zmDateTime/: zmDateTime.c
    ../../../zmFrameWork/Sys/zmDebug/: zmDebugManager.c
    ../../../zmFrameWork/Sys/zmList/: zmList.c
    ../../../zmFrameWork/Sys/zmQueue/: zmFrameQueue.c zmQueueWriter.c
    ../../../zmFrameWork/Sys/zmThread/: zmThread.c
  group 硬件驱动层
    ../HAL/src/: UH_DMA.c UH_GPIO.c UH_Uart.c UH_Sys.c UH_Flash.c UH_PWM_Counter.c UH_ThreadTimer.c UH_I2C.c UH_SPI.c
    ../HAL/: HAL_Config.c
  group 业务逻辑
    ../../Example/: Test.c
